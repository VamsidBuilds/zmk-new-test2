## boards/shields/heatxv2/Kconfig.defconfig
```kconfig
if SHIELD_HEATXV2

config ZMK_KEYBOARD_NAME
    default "Heatxv0.2"

endif # SHIELD_HEATXV2
```
